options:
  parameters:
    author: re
    generate_options: qt_gui
    id: sx8gse
    output_language: python
    title: DVB-GSE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ddgse_ts_bbheader_0
  id: ddgse_ts_bbheader
  parameters:
    file: /dev/dvb/adapter0/dvr0
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    rate1: C1_2
    rate2: C1_3
    rate3: C1_4
    rate4: C1_5_MEDIUM
    rate5: C5_6
    standard: STANDARD_DVBS2
  states: {}
- name: dvbgse_bbheader_sink_0
  id: dvbgse_bbheader_sink
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    rate1: C1_2
    rate2: C1_3
    rate3: C1_4
    rate4: C1_5_MEDIUM
    rate5: C5_6
    standard: STANDARD_DVBS2
  states: {}

connections:
- [ddgse_ts_bbheader_0, '0', dvbgse_bbheader_sink_0, '0']

metadata:
  file_format: 1
